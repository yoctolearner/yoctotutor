require libiec61850.inc

BRANCH = "v1.2"
SRCREV = "cef1360e0509f5b7f9d71e91f899f621e61ef093"

require libiec61850.inc

BRANCH = "v1.4"
SRCREV = "ebdc086b8eeb1ffb336cd7ddb05104e82b6555bb"

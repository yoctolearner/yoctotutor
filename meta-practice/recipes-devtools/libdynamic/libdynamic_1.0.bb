DESCRIPTION = "recipe for the dynamic lib"
LICENSE = "CLOSED"

SRC_URI = "\
    file://math.c \
    file://math.h \
    file://Makefile \
"

S = "${WORKDIR}"

